# Keil uVision project f1bp.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: f1bp +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: .\CMSIS;.\SPL\inc;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
    ./CMSIS/arm/: startup_stm32f10x_cl.s
  group SPL
    ./SPL/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c
  group USER
    ./user/src/: main.c crc.c rs485hal.c hwconf.c rs485.c position_controller.c i2c_enc.c spi_enc.c
